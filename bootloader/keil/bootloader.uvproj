# Keil uVision project bootloader.uvproj, settings and files
target dfu_dual_bank_hci (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: bootloader +hex
  c flags: Optim=4 wLevel=2
  c define: NRF51,DEBUG_NRF_USER,BOARD_NRF6310, BOOTLOADER_BANKED BLE_STACK_SUPPORT_REQD
  c misc: --c99
  c include: ..\;..\include;..\include\hci_transport;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\s110;..\..\..\..\..\Include\sd_common
  memory RVCT4: ROM 0x3c800 size 0x3400
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ../sdk/Source/templates/: system_nrf51.c
    ../src/: arm_startup_nrf51.s
  group Source Code
    ../src/: main.c dfu_dual_bank.c dfu_single_bank.c bootloader.c bootloader_util_arm.c
  group Services
    ../sdk/Source/ble/ble_services/: ble_dfu.c
  group Libraries
    ../sdk/Source/app_common/: app_timer.c app_scheduler.c app_gpiote.c app_button.c crc16.c pstorage.c
    ../sdk/Source/sd_common/: softdevice_handler.c
    ../sdk/Source/ble/: ble_radio_notification.c
  group HCI Transport
    ../src/: dfu_transport_serial.c
    ../sdk/Source/app_common/: hci_transport.c hci_slip.c hci_mem_pool.c app_uart.c
  group BLE Transport
    ../src/: dfu_transport_ble.c
    ../sdk/Source/ble/: ble_conn_params.c ble_advdata.c
    ../sdk/Source/ble/ble_services/: ble_srv_common.c
  group Lava
    ../libraries/lava_bootloader/: lava_bootloader.c
    ../libraries/lava_neopixel/: neopixel.c
    ../libraries/lava_capsense/: mpr121.c sd_twi_hw_master.c
    ../src/: lumen.c
target dfu_single_bank_hci (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: bootloader +hex
  c flags: Optim=4 wLevel=2
  c define: as above
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x3c800 size 0x3400
  memory RVCT9: RAM 0x20002000 size 0x2000
target dfu_dual_bank_ble (ARM-ADS)
  device: nRF51822_xxAA Nordic Semiconductor
  cpu: as above
  output: bootloader +hex
  c flags: Optim=4 wLevel=2
  c define: as above
  c misc: --c99
  c include: ..;..\sdk\Include;..\sdk\Include\sd_common;..\sdk\Include\app_common;..\sdk\Include\ble;..\sdk\Include\ble\ble_services;..\sdk\Include\s110;..\src\include\ble_transport;..\src\include\hci_transport;..\src\include;..\libraries\lava_bootloader;..\libraries\lava_capsense;..\libraries\lava_neopixel
  memory RVCT4: ROM 0x39000 size 0x6c00
  memory RVCT9: RAM 0x20002000 size 0x2000
